# Keil uVision project Master.uvprojx, settings and files
target Master (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8020000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Master +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx,USER_VECT_TAB_ADDRESS
  c misc: --cpu=Cortex-M7.fp.dp --fpu=FPv5_D16
  c include: ../Core/Inc;../Common;../App/motion;../App/ai;../App/cloud;../App/ota;../App/screen;..\App\rule action;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../SYSTEM;../BSP/debug_uart;../BSP/wifi;../BSP/cloud;../BSP/display;../BSP/health;../BSP/w25q128;../Drivers/CMSIS/RTOS2/Include;../X-CUBE-AI/App;../X-CUBE-AI;../Middlewares/ST/AI/Inc
  asm misc: --cpu=Cortex-M7.fp.dp --fpu=FPv5_D16
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x1e0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --cpu=Cortex-M7.fp.dp --fpu=FPv5_D16
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c bootloader_main.c gpio.c freertos.c crc.c dma.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c bootloader_ota.c internal_flash.c
    ../Core/Inc/: bootloader_ota.h internal_flash.h
  group Common
    ../Common/: ota_layout.h crc16.c crc16.h md5.c md5.h ota_info.c ota_info.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP
    ../BSP/cloud/: MqttKit.c MqttKit.h onenet.c onenet.h
    ../BSP/debug_uart/: debug_uart7.c debug_uart7.h uart7_role.h
    ../BSP/display/: uart_screen.c uart_screen.h
    ../BSP/health/: health_monitor.c health_monitor.h
    ../BSP/wifi/: ESP8266.c ESP8266.h
    ../BSP/w25q128/: w25q128.c w25q128.h
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime1020_CM7_Keil.lib
  group APP
    ../App/ai/: motion_ai.c
    ../App/cloud/: cloud_task.c cloud_task.h
    ../App/ota/: ota_config.h ota_http.c ota_http.h ota_service.c ota_service.h
    ../App/motion/: motion_app_events.c motion_app_events.h motion_frame.h motion_input.c motion_input.h motion_mode.h motion_sensor_pipeline.c motion_window_test.c motion_task.c motion_task.h
    ../App/rule action/: rule_action_recognizer.c rule_action_recognizer.h
    ../App/screen/: screen_task.c screen_task.h
  group X-CUBE-AI
    ../X-CUBE-AI/App/: app_x-cube-ai.c app_x-cube-ai.h network.c network.h network_config.h network_data.c network_data.h network_data_params.c network_data_params.h network_generate_report.txt
    ../X-CUBE-AI/: constants_ai.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: yuanzi_usart.c yuanzi_usart.h
    ../SYSTEM/: readme.txt
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Master +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c misc: --cpu=Cortex-M7.fp.dp --fpu=FPv5_D16
  c include: as above
  asm misc: --cpu=Cortex-M7.fp.dp --fpu=FPv5_D16
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --cpu=Cortex-M7.fp.dp --fpu=FPv5_D16
software components: CMSIS:CORE 6.1.1
